# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TYLCU05-S-ETH +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER, CONTROL_TEST_MODE
  c include: .;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;..\..\components\lwip-1.4.1\src;..\..\components\lwip-1.4.1\src\include\ipv4;..\..\components\lwip-1.4.1\src\include\netif;..\..\components\lwip-1.4.1\src\arch\include;..\..\components\lwip-1.4.1\src\include;..\..\components\dfs\include;..\..\components\dfs\filesystems\elmfat;.\Can;.\Eth;.\Trdp;.\Trdp\src\api;.\Trdp\src\vos\api;.\Trdp\src\vos\vxworks;.\Event;.\led;.\CanApp;.\mycan
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: sysVersion.c
  group Drivers
    drivers/: board.c serial.c stm32f4xx_it.c usart.c
    ./drivers/: Bsp_sysspi.c Bsp_at25drv.c crc16.c rtc.c Bsp_bakram.c HwWDog_Max706.c static_mem.c Bsp_systimer.c IAP_updata.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Lwip
    ../../components/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/lwip-1.4.1/src/arch/: sys_arch.c
    ../../components/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group Sd
    ./drivers/: sdio_sd.c fat_service.c
  group File
    ../../components/dfs/filesystems/elmfat/: ff.c dfs_elm.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Eth
    ./Eth/: stm32f4xx_eth.c Eth_Service.c Trdp_Service.c ModBusTcp.c
  group Trdp
    ./Trdp/src/common/: trdp_mdcom.c trdp_stats.c trdp_utils.c trdp_pdcom.c trdp_if.c
    ./Trdp/src/vos/vxworks/: vos_sock.c vos_thread.c
    ./Trdp/src/vos/common/: vos_mem.c vos_utils.c
  group eventRd
    ./Event/: EventRecorder.c EventRecordService.c
  group led
    ./led/: LedHw.c LedTask.c
  group can
    ./mycan/: Bsp_can.c Bsp_can_app.c Bsp_can_rxqueue.c Bsp_can1_txqueue.c Bsp_can2_txqueue.c Bsp_canTask.c common.c Bsp_gpio.c
