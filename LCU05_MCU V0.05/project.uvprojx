# Keil uVision project project.uvprojx, settings and files
target rtthread_stm32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver;.\finsh;.\Drivers;.\Kernel;..\rtthread;.\eclr\include;.\eclr;.\can
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ./Drivers/: board.c Bsp_sysTask.c Bsp_eclrTask.c Bsp_bakram.c Bsp_led.c Bsp_systimer.c cpuusage.c crc16.c rtc.c serial.c startup.c stm32f4xx_it.c Bsp_fsmc.c usart.c Bsp_gpio.c HwWDog_Max706.c userApp.c Bsp_ITempMonit.c
  group STM32_StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_StdPeriph_Driver/: system_stm32f4xx.c startup_stm32f4xx.s
  group Kernel
    ./Kernel/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX_M4
    ./cortex-m4/: backtrace.c context_rvds.S cpuport.c div0.c showmem.c
  group finsh
    ./finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group eCLR
    ./eclr/: eclr_main.cpp eclrEnvironment.cpp eclrImageFile.cpp eCLRLib.lib freertosfile.cpp KWAppInfo.cpp LoadLib.cpp Retarget.c sersocket.cpp sersocket_freeRTOS.cpp threadImpl.cpp
    ./eclr/iolib/: IO_DRIVER_LIB.cpp IO_DRIVER_LIB-cli.cpp
    ./eclr/shmlib/: RT_TICK.cpp RT_TICK-cli.cpp SHM_LIB.cpp SHM_LIB-cli.cpp
  group can
    ./can/: Bsp_can.c Bsp_canTimer.c Bsp_can_rx_Task.c Bsp_can_tx_Task.c Bsp_canTask.c Bsp_canApp.c Bsp_canPrint.c Can_fault_detect.c
